# Repository sherrardTr4129/Wireless-Modular-Haptic-Controller

File README.md:

# Wireless-Modular-Haptic-Controller
A small, flexible and modular wireless haptic controller for mobile manipulator control. This project attempts to take the rudimentary controller design implemented [here](https://github.com/sherrardTr4129/RealSense-BNO055-Pose-Estimation), and add a more complex feature set. Multiple controllers can be used on the same mesh network to create more intuitive human-robot interfaces. Ultimately, the goal of this project is to create a configuration of controllers to provide dexterous control of a mobile manipulator system. 

## Demo Video
Have a look at the system in action! The video below shows a single controller being used for controlling the locobot base with adaptive scaling control. 

## Single Controller Architecture
A given single controller offers much more sensing and actuation capability as compared to the controller design implemented [here](https://github.com/sherrardTr4129/RealSense-BNO055-Pose-Estimation). In this design, each controller acts as a node on a larger mesh network. This allows for ease of addition and subtraction of nodes from said network, depending on the desired HRI configuration. Each controller has the ability to deliver audio (including basic TTS) and vibrotactile feedback to the user. In addition, the controller still contains a BNO055 sensor to extract the orientation of the controller itself in three dimensional space. Each given controller also has two momentary push buttons for user input. Please see the figure below for a graphical depicition of the controller architecture. 

The table below contains a more in-depth explaination of the individual controller architecture, including each sub-system's components.

The individual controller's firmware was designed using a split application level firmware and board support package (BSP) paradigm. All sensor and actuator control drivers were contained within the BSP and could be accessed from a BSP instance within the application level firmware. A graphical depiction of this software architecture can be seen within the figure below.

Once the controller is completely assembled, it should look something like the controller in the figure below. 

## High Level System Architecture
The system is comprised of a single base-station node, and several controller nodes. The base-station node serves as the entry point into the network and coordinates the setup of the overall mesh network (coordinator node). A ROS driver manages data transactions between the ROS infrastructure and the controller mesh network via a serial interface with the coordinator node. The mesh network itself is comprised of wireless XBee modules attached to each controller. These provide a high level of configurability for a relatively low price. Have a look at the data flow diagram below for a simplified explanation of the system's base configuration. 

A brief explanation of the inbound and outbound data types referenced in the above diagram can be seen in the table below.

More controller nodes can be added to the network as needed based on the desired human-robot interface configuration. All data is transmitted in broadcast mode. That is, each node on the network will recieve data transmitted from any individual node. This was done to avoid having to set up direct addressing, and thus increasing the flexibility and ease of setup for the system. Data packets transmitted from a given node are formatted in JSON. One of the JSON fields in any given data packet format is the desired recipient of the data packet. This allows nodes on the network to quickly discern whether to process a given data packet or not using the aforementioned broadcast transmission mode.

## KiCad design electrical_hardware_design/modular_system/wireless-hand-held-controller/wireless-hand-held-controller.kicad_pcb

File electrical_hardware_design/README.md (part):

# Electrical Hardware Design
This sub-directory contains the KiCAD project used to generate the GERBERs needed to manufactor the PCB for the haptic controller. An overview of the PCB design and system BoM can be seen in the sections below.

## PCB Design
The PCB for the controller itself was attempted to be designed to be as modular as possible. For example, each of the sensors and actuators can be dynamically populated and de-populated based on the needs of the given controller within the HRI configuration being constructed. Please note that the PCB was designed with the assumption that it would be manufactored through the use of JLCPCB, so many of the surface mount components are chosen from their inventory system. A picture of the bare PCB can be seen in the image below. 

The overall controller is powered off of a 9V battery, but can handle input voltages up to 12V. Some of the other electical charictoristics of the controller can be seen within the table in the figure below.

## System Bill Of Materials
The overall bill of materials needed to build a single controller can be seen within the table below.

|                    Item                   |                                                                                                                                                                                                          Vendor Link                                                                                                                                                                                                          | Price Per Unit |   Quantity  | Total Price |
|:-----------------------------------------:|:-----------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------:|:--------------:|:-----------:|:-----------:|
| XBee Transceivers                         | [Link](https://www.digikey.com/en/products/detail/digi/XB24CZ7WIT-004/5322374?utm_adgroup=RF%20%26%20RFID&utm_source=google&utm_medium=cpc&utm_campaign=Dynamic%20Search_EN_Product&utm_term=&utm_content=RF%20%26%20RFID&gclid=Cj0KCQjw0K-HBhDDARIsAFJ6UGiYgHiM0G9n1dxsQvZ0bXccxjDMscRyiCRA2ytA907G08f8G45V3yQaAomiEALw_wcB)                                                                                                 | $27.93         | 1           | $27.93      |
| DRV2605L                                  | [Link](https://www.adafruit.com/product/2305?gclid=Cj0KCQjw0K-HBhDDARIsAFJ6UGgZ-WoTEsX5Np_j1WKcjCHPuo7qHZXmB7fjWwpE-o8jy-TSCmtnsTcaAowAEALw_wcB)                                                                                                                                                                                                                                                                              | $7.95          | 1           | $7.95       |
| ERM Pancake Motor                         | [Link](https://www.adafruit.com/product/1201)                                                                                                                                                                                                                                                                                                                                                                                 | $1.95          | 1           | $1.95       |
| 0.5W 8Ohm Speaker                         | [Link](https://www.sparkfun.com/products/15350)                                                                                                                                                                                                                                                                                                                                                                               | $0.95          | 1           | $0.95       |
| Momentary Push Buttons (Pack Of 10)       | [Link](https://www.amazon.com/weideer-Momentary-Self-Reset-Pre-soldered-R13-507-RBK-X/dp/B08SQQWJ5X/ref=sr_1_22_sspa?dchild=1&keywords=push+button+breakout&qid=1626113985&sr=8-22-spons&psc=1&spLa=ZW5jcnlwdGVkUXVhbGlmaWVyPUExSDM2TEZMSUZUNk02JmVuY3J5cHRlZElkPUEwNTU5MjkzM0lXTVZKT005MllRSiZlbmNyeXB0ZWRBZElkPUEwOTM4NjQ5MkVQR1BMU1ZIMzRDUSZ3aWRnZXROYW1lPXNwX2J0ZiZhY3Rpb249Y2xpY2tSZWRpcmVjdCZkb05vdExvZ0NsaWNrPXRydWU=) | $1.00          | 1           | $1.00       |
| Stemma BNO055 Breakout                    | [Link](https://www.adafruit.com/product/4646)                                                                                                                                                                                                                                                                                                                                                                                 | $19.95         | 1           | $19.95      |
| PCB (populated)                           | N/A                                                                                                                                                                                                                                                                                                                                                                                                                           | $15            | 1           | $15         |
| L7805CV                                   | [Link](https://www.amazon.com/L7805CV-Positive-Voltage-Regulator-Output/dp/B09B2D3T2F)                                                                                                                                                                                                                                                                                                                                        | $0.40          | 1           | $0.40       |
| LM386 Breakout                            | [Link](https://www.amazon.com/gp/product/B01FDD3FYQ/ref=ppx_yo_dt_b_asin_title_o00_s00?ie=UTF8&psc=1)                                                                                                                                                                                                                                                                                                                         | $1.598         | 1           | $1.598      |
| Screw Terminals                           | [Link](https://www.amazon.com/gp/product/B07H5G7GC6/ref=ppx_yo_dt_b_asin_title_o09_s00?ie=UTF8&psc=1)                                                                                                                                                                                                                                                                                                                         | $0.17          | 4           | $0.67       |
| Misc Consumables (standoffs, pin headers) | N/A                                                                                                                                                                                                                                                                                                                                                                                                                           | $2             | 1           | $2          |

Parts:
C1, C4: 4.7u; C_0805_2012Metric; LCSC C1779
C2: 330n; C_0805_2012Metric; LCSC C1740
C3, C7: 1u; C_0805_2012Metric; LCSC C28323
C5, C6, C8, C9, C10, C13, C16, C17, C18, C19, C20, C21, C22, C23, C24: 100n; C_0603_1608Metric; LCSC C14663
C11, C12, C14, C15: 15p; C_0603_1608Metric; LCSC C1644
D1: D_Small; D_SMA; LCSC C95872
D2, D3, D4, D5: LED; LED_0805_2012Metric; LCSC C84256
J1: 328P_Prog_Pins; fivePinConn
J2: 328P_Bootloader_Pins; fourPinConn
J3: Input Power; 2-pinScrewTerm
J4: 2560_Prog_Pins; fivePinConn
J5: 2560_Bootloader_Pins; fourPinConn
J6: Speaker Conn; 3-pinScrewTerminal
J7: INT_PWR_CON; 2-pinScrewTerm
J8: External_Interrupts; 2-pinScrewTerm
MOD1: XB24CZ7WIT-004; XBEE-20_THT; MPN XB24CZ7WIT-004; Digi-Key_PN 602-1560-ND
Q1, Q2: BSS138; SOT-23-3; MPN BSS138; Digi-Key_PN BSS138CT-ND
R1, R3, R4, R6, R7, R8: 4.7k; R_0805_2012Metric; LCSC C17673
R2, R5: 10k; R_0603_1608Metric; LCSC C25804
R9, R10, R11, R12: 10k; R_1206_3216Metric; LCSC C17902
U1: L7805CV; TO-220-3; MPN L7805CV; Digi-Key_PN 497-1443-5-ND
U2: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186
U3: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm; LCSC C14877
U4: ATmega2560-16AU; TQFP-100_14x14mm_P0.5mm; LCSC C22460
U5: StemmaBNO055
U6: DRV2605L
Y1, Y2: 16Mhz; Crystal_SMD_2520-4Pin_2.5x2.0mm; LCSC C284159

Connections:
328P_MISO_CON: J2.4, U3.16 (PB4)
328P_MOSI_CON: J2.3, J6.2, U3.15 (PB3)
328P_RESET_CON: C13.1, J2.1, R2.1, U3.29 (~RESET~/PC6)
328P_RX_CON: J1.4, U3.30 (PD0)
328P_SCK_CON: J2.2, U3.17 (PB5)
328P_TX_CON: J1.5, U3.31 (PD1)
328P_XTAL1_CON: C11.1, U3.7 (XTAL1/PB6), Y1.1
328P_XTAL2_CON: C12.1, U3.8 (XTAL2/PB7), Y1.3
2560_MISO_CON: J5.4, U4.22 (PB3)
2560_MOSI_CON: J5.3, U4.21 (PB2)
2560_RESET_CON: C17.1, J5.1, R5.1, U4.30 (~RESET)
2560_RX_CON: J4.4, U4.2 (PE0)
2560_SCK_CON: J5.2, U4.20 (PB1)
2560_SCL_CON: R8.2, U3.28 (PC5), U4.43 (PD0), U5.4 (SCL), U6.3 (SCL)
2560_SDA_CON: R6.2, U3.27 (PC4), U4.44 (PD1), U5.5 (SDA), U6.4 (SDA)
2560_TX_CON: J4.5, U4.3 (PE1)
2560_XTAL1_CON: C14.1, U4.34 (XTAL1), Y2.1
2560_XTAL2_CON: C15.1, U4.33 (XTAL2), Y2.3
+3V3: C4.1, C7.1, C23.1, D3.2 (A), MOD1.1 (Vcc), Q1.1, Q2.1, R9.2, R10.2, U2.2 (VO)
+5V: C1.1, C3.1, C5.1, C8.1, C9.1, C10.1, C18.1, C19.1, C20.1, C21.1, C22.1, C24.2, D2.2 (A), J1.1, J4.1, J7.2, R2.2, R5.2, R6.1, R8.1, R11.2, R12.2, U1.3 (OUT), U2.3 (VI), U3.4 (VCC), U3.6 (VCC), U3.18 (AVCC), U4.10 (VCC), U4.31 (VCC), U4.61 (VCC), U4.80 (VCC), U4.100 (AVCC), U5.1 (Vin), U6.1 (Vin)
+BATT: C2.1, D1.1 (K), U1.1 (IN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, J1.2, J3.1, J4.2, J6.3, J7.1, MOD1.10 (GND), R1.1, R3.1, R4.1, R7.1, U1.2 (GND), U2.1 (GND), U3.3 (GND), U3.5 (GND), U3.21 (GND), U4.11 (GND), U4.32 (GND), U4.62 (GND), U4.81 (GND), U4.99 (GND), U5.3 (GND), U6.2 (GND), Y1.2, Y1.4, Y2.2, Y2.4
INT1_CON: J8.2, U4.6 (PE4)
INT2_CON: J8.1, U4.7 (PE5)
unnamed: C6.1, U3.20 (AREF)
unnamed: C13.2, J1.3
unnamed: C16.1, U4.98 (AREF)
unnamed: C17.2, J4.3
unnamed: D1.2 (A), J3.2
unnamed: D2.1 (K), R1.2
unnamed: D3.1 (K), R3.2
unnamed: D4.1 (K), R4.2
unnamed: D5.1 (K), R7.2
unnamed: D5.2 (A), U4.59 (PC6)
SPKR_NON_INVERTING: J6.1, U3.1 (PD3)
TALKING_STATUS: D4.2 (A), U3.26 (PC3)
XBEE_RX_3.3V: MOD1.3 (DIN/~Config), Q1.2, R10.1
XBEE_RX_5V: Q1.3, R11.1, U4.46 (PD3)
XBEE_TX_3.3V: MOD1.2 (DOUT), Q2.2, R9.1
XBEE_TX_5V: Q2.3, R12.1, U4.45 (PD2)

Notes on the sheet:
ATMEGA328P-AU programming connections
ATMEGA328P-AU MCU Oscillator
Indicator LEDs
input power
Power Rail Regulation
ATMEGA2560 Programming/Bootloader Flash
ATMEGA2560 MCU Oscillator
ATMEGA328P-AU MCU
i2c bus
BNO055 Sensor
DRV2605L Haptic Driver
XBEE
Connections For External Interrupts
XBEE Level Shifting
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
Board: 4 copper layers, 79.4 x 71.1 mm, 60 parts (0 on the bottom side), 40 nets.

## Commit log

2021-07-12 add modular design
2021-07-12 add updated schematic file
2021-07-12 fix broken footprint import
2021-07-19 add logic level shifters for xbee
2021-07-23 add lib file
2021-07-23 add freeCAD file designator to gitignore
2021-07-23 add new mechanical models
2021-07-23 initial commit of main controller firmware
2021-07-25 add vision target model
2021-07-25 add JSON data serialization to firmware
2021-07-25 add *.pyc files to gitignore
2021-07-25 inital commit of ROS driver software
2021-07-25 initial commit of TTS code
2021-07-26 add delays and speach pauses
2021-07-26 add i2c support for TTS processor
2021-07-26 complete main controller TTS control
2021-07-26 add documentation
2021-07-26 add comments
2021-07-26 add include gaurds
2021-07-27 complete outbound JSON data manager class implementation
2021-07-27 inbound JSON parsing now working
2021-07-27 reimplement driver as class structure
2021-07-27 implemented voice and haptic ROS service call
2021-07-27 add interrupt debouncing
2021-07-28 fix incorrect baud rate
2021-07-28 remove old global variables
2021-07-28 initial commit of locobot haptic control package
2021-07-28 add handling of button press events
2021-07-29 initial commit of haptic_base_control package
2021-07-29 expose serial port as ROS param
2021-07-29 initial commit of haptic control launch file
2021-07-29 remove .xml from gitignore
2021-07-29 add package.xml files to packages
2021-07-29 change way port is exposed as param
2021-07-29 fix scaling issues
2021-07-29 fixed a few typos
2021-07-29 fixed scaling method
2021-07-29 change how robot bringup happens to better reflect usecase
2021-08-01 swap button events, extend angle range
2021-08-01 add two new TTS events
2021-08-22 Create deleteme
2021-08-24 remove LiDAR bringup, add in base-station driver
